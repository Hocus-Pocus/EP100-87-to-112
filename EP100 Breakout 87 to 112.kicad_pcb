# Repository Hocus-Pocus/EP100-87-to-112

## KiCad design EP100 Breakout 87 to 112.kicad_pcb

Parts:
C1, C4, C5, C6, C7, C10: 0.1uF
C2, C3, C8, C9: 22uF
D1, D2, D3, D6, D7: Red
D4: Grn
D5: Yel
J1: SCI1
J2: SCI2
K1: CONN_3
P1, P5, P9: CONN_2
P2, P3, P6, P7: CONN_4
P4: CONN_13X2
P8: CONN_6
Q1, Q2, Q3, Q4, Q5: ZTX450; TO92
R1, R3, R5, R13, R14, R15, R16, R17, R18, R20, R21, R22, R23, R24, R29, R31: 1k
R2, R4, R6, R30, R32: 100k
R7, R33: 120R
R8, R9, R10, R11, R12, R19, R25, R26, R27, R28: 2.4k
SW1, SW3: SPST
SW2, SW4: 6MM-TACT_SW
U1, U3: TJA1042
U2: MAX3232EEPE+

Connections:
+12V: K1.1, R8.2, R9.2, R10.2, R19.1, R27.2, R28.2
/MISO0: P4.17, P8.4
/MOSI0: P4.16, P8.3
/PJ6: P4.12, R24.1
/PJ7: P4.13, R17.1
/PK7: P4.5, R3.2
/PM0: P4.6, U1.4 (RXD)
/PM1: P4.7, R13.2, U1.1 (TXD)
/PM2: P4.8, U3.4 (RXD)
/PM3: P4.9, R20.2, U3.1 (TXD)
/PM4: P4.10, R22.1
/PM5: P4.11, R15.1
/PM6: P4.22, P5.1
/PM7: P4.23, P5.2 (PM)
/PP4: P3.2, P4.1
/PP5: P4.2, P6.2
/PP6: P2.2, P4.3
/PP7: P4.4, P7.2
/PS0: P4.21, U2.12 (R1out)
/PS1: P4.20, U2.11 (T1in)
/PS2: P4.19, U2.9 (R2out)
/PS3: P4.18, U2.10 (T2in)
/PS6: P4.15, P8.2
/PS7: P4.14, P8.1
GND: C1.2, C2.2, C3.2, C5.1, C8.2, C9.2, C10.2, D4.2 (K), D5.2 (K), J1.5, J1.9, J2.5, J2.9, K1.3, P4.26, P8.6, Q1.1 (E), Q2.1 (E), Q3.1 (E), Q4.1 (E), Q5.1 (E), R2.2, R4.2, R6.2, R30.2, R32.2, SW1.2, SW2.3, SW3.2, SW4.3, U1.2 (Gnd), U1.8 (STB), U2.15 (Gnd), U3.2 (Gnd), U3.8 (STB)
unnamed: P6.3, R25.2
unnamed: P6.1, R29.2
unnamed: Q5.3 (B), R31.1, R32.1
unnamed: D7.2 (K), Q5.2 (C)
unnamed: D7.1 (A), R28.1
unnamed: Q4.3 (B), R29.1, R30.1
unnamed: P2.1, R1.2
unnamed: D6.2 (K), Q4.2 (C)
unnamed: D6.1 (A), R27.1
unnamed: R21.2, R22.2, SW3.1
unnamed: P7.3, R26.2
unnamed: P7.1, R31.2
unnamed: R23.2, R24.2, SW4.1
unnamed: R16.2, R17.2, SW2.1
unnamed: J2.3, U2.8 (R2in)
unnamed: J2.2, U2.7 (T2out)
unnamed: D1.2 (K), Q1.2 (C)
unnamed: Q1.3 (B), R1.1, R2.1
unnamed: D1.1 (A), R8.1
unnamed: P2.3, R11.2
unnamed: D2.1 (A), R9.1
unnamed: R14.2, R15.2, SW1.1
unnamed: Q2.3 (B), R3.1, R4.1
unnamed: D2.2 (K), Q2.2 (C)
unnamed: J1.3, U2.13 (R1in)
unnamed: J1.2, U2.14 (T1out)
unnamed: C6.1, U2.2 (V+)
unnamed: D4.1 (A), R18.2
unnamed: D5.1 (A), R19.2
unnamed: C7.1, U2.1 (C1+)
unnamed: C7.2, U2.3 (C1-)
unnamed: C4.1, U2.5 (C2-)
unnamed: C4.2, U2.4 (C2+)
unnamed: C5.2, U2.6 (V-)
unnamed: P9.1, R33.1, U3.7 (CANH)
unnamed: P9.2 (PM), R33.2, U3.6 (CANL)
unnamed: D3.2 (K), Q3.2 (C)
unnamed: D3.1 (A), R10.1
unnamed: P3.1, R5.2
unnamed: C3.1, P3.4, R12.1
unnamed: Q3.3 (B), R5.1, R6.1
unnamed: P3.3, R12.2
unnamed: P1.2 (PM), R7.2, U1.6 (CANL)
unnamed: C2.1, P2.4, R11.1
unnamed: P1.1, R7.1, U1.7 (CANH)
unnamed: C9.1, P7.4, R26.1
unnamed: C8.1, P6.4, R25.1
VDD: C1.1, C6.2, C10.1, J1.1, J2.1, K1.2 (PM), P4.25, P8.5, R13.1, R14.1, R16.1, R18.1, R20.1, R21.1, R23.1, U1.3 (VDD), U2.16 (VCC), U3.3 (VDD)

Notes on the sheet:
LED output jumper pins 1 and 2 Analog V out jumper pins 2 and 3 Analog V out on pin 4
RXD0
TXD0
RXD1
TXD1
CANH
CANL
RXCAN0
TXCAN0
TXCAN1
RXCAN1
TIM1OC4
TIM1OC6
SCK0
MISO0
TXD3
RXD3
MOSI0
SS0
TIM1OC7
TIM1OC5
Spare SCI Header
Socket for SD card module
Tuner Studio
Digital Dash

Board: 2 copper layers, 87.6 x 95.2 mm, 78 parts (0 on the bottom side), 73 nets.

Other parts of the board:
Hole .125, Hole .125#2, Hole .125#3, Hole .125#4: P***; Hole.125
